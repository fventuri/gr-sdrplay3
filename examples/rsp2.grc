options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSP2 test
    generate_options: qt_gui
    id: rsp2
    output_language: python
    title: RSP2 test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sdrplay3_rsp2_0
  id: sdrplay3_rsp2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Hi-Z
    bandwidth: '0'
    biasT: 'False'
    center_freq: 1010e3
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: '**********'
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [sdrplay3_rsp2_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
