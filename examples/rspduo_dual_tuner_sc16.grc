options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSPduo Dual Tuner test
    generate_options: qt_gui
    id: rspduo_dual_tuner
    output_language: python
    title: RSPduo Dual Tuner test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: short
    vlen: '2'
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: '0'
    center_freq0: 100e6
    center_freq1: 146.520e6
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: sc16
    rf_gRdB: '0'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Dual Tuner (independent RX)
    sample_rate: 62.5e3
    sample_rate_non_single_tuner: 2000e3
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [sdrplay3_rspduo_0, '0', blocks_null_sink_1, '0']
- [sdrplay3_rspduo_0, '1', blocks_null_sink_1, '1']

metadata:
  file_format: 1
