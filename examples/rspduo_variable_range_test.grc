options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSPduo variable range test
    generate_options: qt_gui
    id: rspduo_variable_range_test
    output_language: python
    title: RSPduo variable range test
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 62.5e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: High Z
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    bulk_transfer_mode: 'False'
    center_freq: freq
    center_freq0: '0'
    center_freq1: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'True'
    freq_corr: '0'
    if_gRdB: '59'
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRdB: '20'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rf_notch_filter: 'False'
    rsp_selector: '**********'
    rspduo_mode: Single Tuner
    sample_rate: samp_rate
    sample_rate_non_single_tuner: 62.5e3
    sample_sequence_gaps_check: 'True'
    show_gain_changes: 'False'
  states: {}

connections:
- [sdrplay3_rspduo_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
