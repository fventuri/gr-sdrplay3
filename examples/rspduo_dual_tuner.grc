options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSPduo Dual Tuner test
    generate_options: qt_gui
    id: rspduo_dual_tuner
    output_language: python
    title: RSPduo Dual Tuner test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    center_freq: '0'
    center_freq0: 100e6
    center_freq1: 146.520e6
    if_gRdB: '40'
    if_gRdB0: '40'
    if_gRdB1: '40'
    output_type: fc32
    rf_gRdB: '0'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rsp_selector: '**********'
    rspduo_mode: Dual Tuner (independent RX)
    sample_rate: 62.5e3
    sample_rate_non_single_tuner: 2000e3
  states: {}

connections:
- [sdrplay3_rspduo_0, '0', qtgui_freq_sink_x_0, '0']
- [sdrplay3_rspduo_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
