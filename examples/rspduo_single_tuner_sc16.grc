options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSPduo Single Tuner test
    generate_options: qt_gui
    id: rspduo_single_tuner
    output_language: python
    title: RSPduo Single Tuner test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
    vlen: '2'
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    antenna: High Z
    antenna_both: Both Tuners
    bandwidth: '0'
    center_freq: 1010e3
    center_freq0: '0'
    center_freq1: '0'
    if_gRdB: '40'
    if_gRdB0: '40'
    if_gRdB1: '40'
    output_type: sc16
    rf_gRdB: '0'
    rf_gRdB0: '0'
    rf_gRdB1: '0'
    rsp_selector: '**********'
    rspduo_mode: Single Tuner
    sample_rate: 2000e3
    sample_rate_non_single_tuner: 62.5e3
  states: {}

connections:
- [sdrplay3_rspduo_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
