options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSP1 test
    generate_options: qt_gui
    id: rsp1
    output_language: python
    title: RSP1 test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sdrplay3_rsp1_0
  id: sdrplay3_rsp1
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    bandwidth: '0'
    center_freq: 1010e3
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRdB: '0'
    rsp_selector: '""'
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [sdrplay3_rsp1_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
