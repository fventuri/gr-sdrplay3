options:
  parameters:
    author: Franco Venturi
    copyright: Franco Venturi
    description: RSPduo Dual Tuner test (diversity reception)
    generate_options: qt_gui
    id: rspduo_dual_tuner_diversity_reception
    output_language: python
    title: RSPduo Dual Tuner test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: 100e6
    center_freq0: 100e6
    center_freq1: 146.520e6
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '0'
    rf_gR0: LNA3
    rf_gR1: LNA3
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Dual Tuner (diversity reception)
    sample_rate: 62.5e3
    sample_rate_non_single_tuner: 2000e3
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [sdrplay3_rspduo_0, '0', qtgui_freq_sink_x_0, '0']
- [sdrplay3_rspduo_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-34-g95ee7221
